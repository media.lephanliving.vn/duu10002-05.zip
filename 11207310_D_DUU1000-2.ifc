Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-10-16T11:09:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 16 11:09:21 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{F0890C5C-38A1-4249-A8ED-5016D77AEF6F}\ifc * Database version: 5507 * Database creation date: Fri Oct 16 11:09:18 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 16 11:09:18 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 16 11:09:18 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28996403_D_11207310_DUU1000-2, 11207310_D_DUU1000-2:28996403_D_11207310_DUU1000-2:202201
In: Level 1
Type - Material: Thermoplastic Resin, z_Miele_Design_Zinc_Steel, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - Reference: 28996403_D_11207310_DUU1000-2
